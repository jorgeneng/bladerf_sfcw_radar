options:
  parameters:
    generate_options: qt_gui
    id: testMultitarget
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: burst_len
  id: variable
  parameters:
    value: 2**11
  states: {}
- name: ini_offset
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: int(burst_len/2)
    value: '0'
  states: {}
- name: mf_size
  id: variable
  parameters:
    value: 2**8
  states: {}
- name: num_steps
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: mf_size
    n: burst_len
    offset: ini_offset
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_0
  id: blocks_keep_m_in_n
  parameters:
    m: mf_size
    n: burst_len
    offset: ini_offset
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: mf_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: mf_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: mf_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: num_steps
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: mf_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: num_steps
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: 200*10
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: num_steps
    srate: samp_rate
    type: complex
  states: {}
- name: sfcwRadar_calibration_0
  id: sfcwRadar_calibration
  parameters:
    cal_fileName: '"cal_64k_0.npy"'
    isOff: '0'
    num_steps: num_steps
  states: {}
- name: sfcwRadar_matchedFilter_0
  id: sfcwRadar_matchedFilter
  parameters:
    mf_size: mf_size
  states: {}
- name: sfcwRadar_rangeProfileSink_0
  id: sfcwRadar_rangeProfileSink
  parameters:
    num_steps: num_steps
    prefix: cal_64k
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_keep_m_in_n_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_stream_to_vector_0, '0', sfcwRadar_matchedFilter_0, '0']
- [blocks_stream_to_vector_0_0, '0', sfcwRadar_matchedFilter_0, '1']
- [blocks_stream_to_vector_1, '0', sfcwRadar_calibration_0, '0']
- [blocks_stream_to_vector_1, '0', sfcwRadar_rangeProfileSink_0, '0']
- [blocks_throttle2_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_throttle2_0, '0', blocks_keep_m_in_n_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_stream_1, '0', qtgui_time_sink_x_0_0, '0']
- [sfcwRadar_calibration_0, '0', blocks_vector_to_stream_1, '0']
- [sfcwRadar_matchedFilter_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.9.2-39-gcf065ee5
