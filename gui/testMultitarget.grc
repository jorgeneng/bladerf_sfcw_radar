options:
  parameters:
    generate_options: qt_gui
    id: testMultitarget
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: a_1
  id: variable_qtgui_range
  parameters:
    label: reflection_amp_1
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: a_2
  id: variable_qtgui_range
  parameters:
    label: reflection_amp_2
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: cw_freq
  id: variable_qtgui_range
  parameters:
    label: cw_freq
    start: 1e3
    step: '100'
    stop: 100e3
    value: 1e3
  states: {}
- name: p_1
  id: variable_qtgui_range
  parameters:
    label: reflection_phase_1
    start: '0'
    step: '0.1'
    stop: '4'
    value: '0'
  states: {}
- name: p_2
  id: variable_qtgui_range
  parameters:
    label: reflection_phase_2
    start: '0'
    step: '0.1'
    stop: '4'
    value: '0'
  states: {}
- name: ref_amp
  id: variable_qtgui_range
  parameters:
    label: ref_amp
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: ref_phase
  id: variable_qtgui_range
  parameters:
    label: ref_phase
    start: '0'
    step: '0.1'
    stop: '4'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: cw_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: a_1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: a_2
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ref_amp
    type: complex
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: p_1
  states: {}
- name: blocks_phase_shift_0_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: p_2
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"rx"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"ref"'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"PhaseDiff"'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Phase
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_arg_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_phase_shift_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_phase_shift_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_phase_shift_0, '0', blocks_add_xx_0, '0']
- [blocks_phase_shift_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_phase_shift_0_0, '0', blocks_add_xx_0, '1']
- [blocks_phase_shift_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_throttle2_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_const_vxx_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.9.2-39-gcf065ee5
