options:
  parameters:
    generate_options: no_gui
    id: testRangeProfileSink
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 100e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '128'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: num_steps
  id: parameter
  parameters:
    type: intx
    value: '128'
  states: {}
- name: server_ip
  id: parameter
  parameters:
    type: str
    value: localhost
  states: {}
- name: server_port
  id: parameter
  parameters:
    type: intx
    value: '9999'
  states: {}
- name: sfcwRadar_rangeProfileSink_0
  id: sfcwRadar_rangeProfileSink
  parameters:
    num_steps: num_steps
    prefix: prefix
    server_ip: server_ip
    server_port: server_port
    upload_to_server: upload_to_server
  states: {}
- name: upload_to_server
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_vector_0, '0', sfcwRadar_rangeProfileSink_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.9.2-39-gcf065ee5
