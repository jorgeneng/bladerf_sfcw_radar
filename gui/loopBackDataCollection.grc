options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: sfcw_radar_gui
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: burst_len
  id: variable
  parameters:
    value: 2**10
  states: {}
- name: chirp_bandwidth
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: cut_off
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    start: '0'
    step: '1'
    stop: chirp_bandwidth*2
    value: chirp_bandwidth*1.2
    widget: eng
  states: {}
- name: cw_freq
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: file_prefix
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,2,1,1
    type: string
    value: /home/hui/bladerf_sfcw_radar/data/test_channel_extractor
  states: {}
- name: freq_step
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: isChirp
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: lp_dec
  id: variable
  parameters:
    value: '1'
  states: {}
- name: mf_size
  id: variable
  parameters:
    value: recv_buf_len
  states: {}
- name: num_steps
  id: variable
  parameters:
    value: '128'
  states: {}
- name: pulse_amp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: recv_buf_len
  id: variable
  parameters:
    value: burst_len
  states: {}
- name: ref_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '20'
    widget: eng
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '20'
    widget: eng
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: start_freq
  id: variable
  parameters:
    value: 1e9
  states: {}
- name: transition_width
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    start: '0'
    step: '1'
    stop: chirp_bandwidth
    value: chirp_bandwidth/2
    widget: eng
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '20'
    widget: eng
  states: {}
- name: blocks_complex_to_arg_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_stream_to_vector_1_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: recv_buf_len*num_steps
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: recv_buf_len*num_steps
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_off
    decim: lp_dec
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_off
    decim: lp_dec
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color3: cyan
    label1: out0_real
    label2: out0_imag
    label3: out1_real
    label4: out1_imag
    name: '"Reference/Echo signals in time domain"'
    nconnections: '2'
    size: int(recv_buf_len*num_steps/lp_dec)
    srate: samp_rate
    style4: '2'
    type: complex
  states: {}
- name: scan_cont
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: 1,3,1,1
    msgName: ''
    type: int
    value: '2'
  states: {}
- name: scan_once
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: 2,3,1,1
    msgName: ''
    type: int
    value: '1'
  states: {}
- name: sfcwRadar_rangeProfileSink_1
  id: sfcwRadar_rangeProfileSink
  parameters:
    num_steps: num_steps
    prefix: scan
    server_ip: localhost
    server_port: '9999'
    upload_to_server: 'False'
  states: {state: disabled}
- name: sfcwRadar_rawSamplesSink_0
  id: sfcwRadar_rawSamplesSink
  parameters:
    burst_len: burst_len
    chirp_bandwidth: chirp_bandwidth
    cw_amplitude: pulse_amp
    cw_frequency: cw_freq
    enable_biastee: 'False'
    file_prefix: file_prefix
    isChirp: isChirp
    num_steps: num_steps
    recv_buf_len: recv_buf_len
    ref_gain: ref_gain
    rx_gain: rx_gain
    samp_rate: int(samp_rate)
    start_freq: int(start_freq)
    tx_gain: tx_gain
  states: {}
- name: sfcwRadar_sfcw_radar_cc_0
  id: sfcwRadar_sfcw_radar_cc
  parameters:
    buffer_size: '2048'
    burst_len: burst_len
    chirp_bandwidth: int(chirp_bandwidth)
    cw_frequency: cw_freq
    enable_biastee: 'False'
    isChirp: isChirp
    num_buffers: '8'
    num_steps: num_steps
    num_transfers: '4'
    pulse_amplitude: pulse_amp
    recv_buf_len: recv_buf_len
    ref_gain: ref_gain
    rx_gain: rx_gain
    samp_rate: int(samp_rate)
    schedule_delay_ms: '1'
    start_freq: int(start_freq)
    step_size: int(freq_step)
    tx_gain: tx_gain
  states: {}

connections:
- [blocks_stream_to_vector_1_0_0, '0', sfcwRadar_rawSamplesSink_0, '0']
- [blocks_stream_to_vector_1_0_1, '0', sfcwRadar_rawSamplesSink_0, '1']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [low_pass_filter_0_0, '0', qtgui_time_sink_x_1, '1']
- [scan_cont, pressed, sfcwRadar_sfcw_radar_cc_0, scan]
- [scan_once, pressed, sfcwRadar_sfcw_radar_cc_0, scan]
- [sfcwRadar_sfcw_radar_cc_0, '0', blocks_stream_to_vector_1_0_0, '0']
- [sfcwRadar_sfcw_radar_cc_0, '0', low_pass_filter_0, '0']
- [sfcwRadar_sfcw_radar_cc_0, '1', blocks_stream_to_vector_1_0_1, '0']
- [sfcwRadar_sfcw_radar_cc_0, '1', low_pass_filter_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
