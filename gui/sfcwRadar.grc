options:
  parameters:
    generate_options: qt_gui
    id: sfcw_radar_gui
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: burst_len
  id: variable
  parameters:
    value: 2**9
  states: {}
- name: calibration_off
  id: variable_qtgui_entry
  parameters:
    label: calibration_off
    type: int
    value: '0'
  states: {state: disabled}
- name: chirp_bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,4,1,1
    start: '0'
    step: '1'
    stop: samp_rate/4
    value: 1e6
    widget: eng
  states: {state: disabled}
- name: chirp_bandwidth
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: cut_off
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    start: '0'
    step: '1'
    stop: chirp_bandwidth*2
    value: chirp_bandwidth
    widget: eng
  states: {}
- name: cw_freq
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: file_prefix
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,2,1,1
    type: string
    value: '0'
  states: {}
- name: freq_step
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: lp_dec
  id: variable
  parameters:
    value: '1'
  states: {}
- name: mf_size
  id: variable
  parameters:
    value: recv_buf_len
  states: {}
- name: num_steps
  id: variable
  parameters:
    value: '128'
  states: {}
- name: pulse_amp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: recv_buf_len
  id: variable
  parameters:
    value: burst_len+64
  states: {}
- name: ref_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '20'
    widget: eng
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '20'
    widget: eng
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: scale
  id: variable_qtgui_range
  parameters:
    label: B-scan scale
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: start_freq
  id: variable
  parameters:
    value: 1e9
  states: {}
- name: transition_width
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    start: '0'
    step: '1'
    stop: chirp_bandwidth
    value: chirp_bandwidth
    widget: eng
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '20'
    widget: eng
  states: {}
- name: blocks_complex_to_arg_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_1_0
  id: blocks_complex_to_arg
  parameters:
    vlen: num_steps
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {state: bypassed}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {state: bypassed}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_steps
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: int(mf_size/lp_dec)
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(mf_size/lp_dec)
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: recv_buf_len*num_steps
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_1_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: recv_buf_len*num_steps
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_steps
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: num_steps
    type: float
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: num_steps
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(num_steps)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_off
    decim: lp_dec
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_off
    decim: lp_dec
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
    wintype: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,2,1,2
    mult: '[scale]'
    name: '"B-Scan"'
    ncols: num_steps
    nrows: '15'
    samp_rate: samp_rate
    type: float
    update_time: '0.1'
    zmin: '0'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color3: cyan
    label1: out0_real
    label2: out0_imag
    label3: out1_real
    label4: out1_imag
    name: '"Reference/Echo signals in time domain"'
    nconnections: '2'
    size: int(recv_buf_len*num_steps/lp_dec)
    srate: samp_rate
    style4: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 0,0,1,2
    name: '"Range profile(A-Scan)"'
    size: num_steps
    srate: samp_rate
    type: float
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"Phase of each frequency step"'
    size: num_steps
    srate: samp_rate
    type: float
    ylabel: Phase
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: scan_cont
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: 1,3,1,1
    msgName: ''
    type: int
    value: '2'
  states: {}
- name: scan_once
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: 2,3,1,1
    msgName: ''
    type: int
    value: '1'
  states: {}
- name: sfcwRadar_bladerfRadarController_cc_0
  id: sfcwRadar_bladerfRadarController_cc
  parameters:
    buffer_size: '2048'
    burst_len: burst_len
    chirp_bandwidth: chirp_bandwidth
    cw_amplitude: cw_amp
    cw_frequency: cw_freq
    enable_biastee: 'True'
    isChirp: 'True'
    num_buffers: '8'
    num_steps: num_steps
    num_transfers: '4'
    recv_buf_len: recv_buf_len
    ref_gain: ref_gain
    rx_gain: rx_gain
    samp_rate: int(samp_rate)
    start_freq: int(start_freq)
    step_size: int(freq_step)
    ts_inc_recv: '0'
    ts_inc_send: '1'
    tx_gain: tx_gain
  states: {state: disabled}
- name: sfcwRadar_calibration_0
  id: sfcwRadar_calibration
  parameters:
    cal_fileName: cal_1.npy
    isOff: calibration_off
    num_steps: num_steps
  states: {state: disabled}
- name: sfcwRadar_findPeak_0
  id: sfcwRadar_findPeak
  parameters:
    mf_size: int(mf_size/lp_dec)
  states: {}
- name: sfcwRadar_matchedFilter_0
  id: sfcwRadar_matchedFilter
  parameters:
    mf_size: int(mf_size/lp_dec)
  states: {}
- name: sfcwRadar_rangeProfileSink_1
  id: sfcwRadar_rangeProfileSink
  parameters:
    num_steps: num_steps
    prefix: scan
    server_ip: localhost
    server_port: '9999'
    upload_to_server: 'False'
  states: {state: disabled}
- name: sfcwRadar_rangeProfileSink_1_0
  id: sfcwRadar_rangeProfileSink
  parameters:
    num_steps: num_steps
    prefix: cal
    server_ip: localhost
    server_port: '9999'
    upload_to_server: 'False'
  states: {state: disabled}
- name: sfcwRadar_rawSamplesSink_0
  id: sfcwRadar_rawSamplesSink
  parameters:
    burst_len: burst_len
    chirp_bandwidth: chirp_bandwidth
    cw_amplitude: cw_amp
    cw_frequency: cw_freq
    enable_biastee: 'False'
    file_prefix: file_prefix
    isChirp: 'True'
    num_steps: num_steps
    recv_buf_len: recv_buf_len
    ref_gain: ref_gain
    rx_gain: rx_gain
    samp_rate: int(samp_rate)
    start_freq: int(start_freq)
    tx_gain: tx_gain
  states: {state: disabled}
- name: sfcwRadar_sfcw_radar_cc_0
  id: sfcwRadar_sfcw_radar_cc
  parameters:
    buffer_size: '2048'
    burst_len: burst_len
    chirp_bandwidth: int(chirp_bandwidth)
    cw_frequency: cw_freq
    enable_biastee: 'True'
    isChirp: 'True'
    num_buffers: '8'
    num_steps: num_steps
    num_transfers: '4'
    pulse_amplitude: pulse_amp
    recv_buf_len: recv_buf_len
    ref_gain: ref_gain
    rx_gain: rx_gain
    samp_rate: int(samp_rate)
    start_freq: int(start_freq)
    step_size: int(freq_step)
    ts_inc_send: '1'
    tx_gain: tx_gain
  states: {}
- name: sfcwRadar_sfcw_radar_mimo_cc_0
  id: sfcwRadar_sfcw_radar_mimo_cc
  parameters:
    buffer_size: '1024'
    burst_len: burst_len
    chirp_bandwidth: chirp_bandwidth
    cw_frequency: cw_freq
    enable_biastee: 'True'
    isChirp: 'True'
    num_buffers: '8'
    num_steps: num_steps
    num_transfers: '4'
    pulse_amplitude: pulse_amp
    recv_buf_len: recv_buf_len
    ref_gain: ref_gain
    rx_gain: rx_gain
    samp_rate: int(samp_rate)
    start_freq: int(start_freq)
    step_size: int(freq_step)
    ts_inc_send: '1'
    tx_gain: tx_gain
  states: {}

connections:
- [blocks_complex_to_arg_1, '0', qtgui_time_sink_x_2, '0']
- [blocks_complex_to_arg_1_0, '0', blocks_vector_to_stream_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0, '0', sfcwRadar_calibration_0, '0']
- [blocks_stream_to_vector_0, '0', sfcwRadar_rangeProfileSink_1_0, '0']
- [blocks_stream_to_vector_1, '0', sfcwRadar_matchedFilter_0, '0']
- [blocks_stream_to_vector_1_0, '0', sfcwRadar_matchedFilter_0, '1']
- [blocks_stream_to_vector_1_0_0, '0', sfcwRadar_rawSamplesSink_0, '1']
- [blocks_stream_to_vector_1_0_1, '0', sfcwRadar_rawSamplesSink_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_vector_to_stream_1, '0', qtgui_time_sink_x_2, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0, '0', sfcwRadar_rangeProfileSink_1, '0']
- [low_pass_filter_0, '0', blocks_stream_to_vector_1, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [low_pass_filter_0_0, '0', blocks_stream_to_vector_1_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0, '1']
- [low_pass_filter_0_0, '0', qtgui_time_sink_x_1, '1']
- [scan_cont, pressed, sfcwRadar_bladerfRadarController_cc_0, scan]
- [scan_cont, pressed, sfcwRadar_sfcw_radar_cc_0, scan]
- [scan_cont, pressed, sfcwRadar_sfcw_radar_mimo_cc_0, scan]
- [scan_once, pressed, sfcwRadar_bladerfRadarController_cc_0, scan]
- [scan_once, pressed, sfcwRadar_sfcw_radar_cc_0, scan]
- [scan_once, pressed, sfcwRadar_sfcw_radar_mimo_cc_0, scan]
- [sfcwRadar_bladerfRadarController_cc_0, '0', blocks_stream_to_vector_1_0_0, '0']
- [sfcwRadar_bladerfRadarController_cc_0, '0', low_pass_filter_0, '0']
- [sfcwRadar_bladerfRadarController_cc_0, '1', blocks_stream_to_vector_1_0_1, '0']
- [sfcwRadar_bladerfRadarController_cc_0, '1', low_pass_filter_0_0, '0']
- [sfcwRadar_calibration_0, '0', blocks_complex_to_arg_1_0, '0']
- [sfcwRadar_calibration_0, '0', fft_vxx_0, '0']
- [sfcwRadar_findPeak_0, '0', blocks_complex_to_arg_1, '0']
- [sfcwRadar_findPeak_0, '0', blocks_stream_to_vector_0, '0']
- [sfcwRadar_matchedFilter_0, '0', sfcwRadar_findPeak_0, '0']
- [sfcwRadar_sfcw_radar_cc_0, '0', low_pass_filter_0, '0']
- [sfcwRadar_sfcw_radar_cc_0, '1', low_pass_filter_0_0, '0']
- [sfcwRadar_sfcw_radar_mimo_cc_0, '0', low_pass_filter_0, '0']
- [sfcwRadar_sfcw_radar_mimo_cc_0, '1', low_pass_filter_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.9.2-39-gcf065ee5
