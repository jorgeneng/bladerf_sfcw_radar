options:
  parameters:
    generate_options: qt_gui
    id: sfcwRadarGUI
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: burst_len
  id: variable
  parameters:
    value: 2**10
  states: {}
- name: calibration_off
  id: variable_qtgui_entry
  parameters:
    label: calibration_off
    type: int
    value: '0'
  states: {state: disabled}
- name: chirp_bandwidth
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: cut_off
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: chirp_bandwidth
    value: chirp_bandwidth/2
  states: {}
- name: cw_amp
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: cw_freq
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: freq_step
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: initial_offset
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: burst_len-mf_size
    value: '512'
  states: {state: disabled}
- name: mf_delay
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: mf_size
    value: '0'
  states: {}
- name: mf_size
  id: variable
  parameters:
    value: recv_buf_len
  states: {}
- name: num_steps
  id: variable
  parameters:
    value: '64'
  states: {}
- name: recv_buf_len
  id: variable
  parameters:
    value: 2**10+512
  states: {}
- name: ref_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: start_freq
  id: variable
  parameters:
    value: 1e9
  states: {}
- name: transition_width
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: 1e6
    value: 200e3
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '40'
  states: {state: disabled}
- name: tx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: y_max
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: blocks_complex_to_arg_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_steps
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: mf_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: mf_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: recv_buf_len*num_steps
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: recv_buf_len*num_steps
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_steps
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: num_steps
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.hamming(num_steps)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: cut_off
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition_width
    win: window.WIN_KAISER
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: chirp_bandwidth/1.8
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: chirp_bandwidth/10
    win: window.WIN_KAISER
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '2'
    grid: 'True'
    gui_hint: 2,2,5,2
    name: '"B-Scan"'
    ncols: num_steps
    nrows: '15'
    samp_rate: samp_rate
    type: float
    update_time: '0.1'
    zmax: y_max
    zmin: '0'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color3: cyan
    gui_hint: 0,0,1,2
    label1: rx_real_rx
    label2: rx_img_rx
    label3: rx_real_ref
    label4: rx_imag_ref
    name: '"Reference/Echo signals in time domain"'
    nconnections: '2'
    size: int(recv_buf_len*num_steps)
    srate: samp_rate
    style4: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 2,0,5,2
    name: '"Range profile(A-Scan)"'
    size: num_steps
    srate: samp_rate
    type: float
    ymax: y_max
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,2,1,2
    name: '"Phase of each frequency step"'
    size: num_steps
    srate: samp_rate
    type: float
    ylabel: Phase
    ymax: '4'
    ymin: '-4'
  states: {}
- name: scan_cont
  id: variable_qtgui_msg_push_button
  parameters:
    msgName: ''
    type: int
    value: '2'
  states: {}
- name: scan_once
  id: variable_qtgui_msg_push_button
  parameters:
    msgName: ''
    type: int
    value: '1'
  states: {}
- name: sfcwRadar_bladerfRadarController_cc_0
  id: sfcwRadar_bladerfRadarController_cc
  parameters:
    buffer_size: '2048'
    burst_len: burst_len
    chirp_bandwidth: chirp_bandwidth
    cw_amplitude: cw_amp
    cw_frequency: cw_freq
    enable_biastee: 'False'
    isChirp: 'True'
    num_buffers: '8'
    num_steps: num_steps
    num_transfers: '4'
    recv_buf_len: recv_buf_len
    ref_gain: ref_gain
    rx_gain: rx_gain
    samp_rate: int(samp_rate)
    start_freq: int(start_freq)
    step_size: int(freq_step)
    ts_inc_recv: '0'
    ts_inc_send: '1'
    tx_gain: tx_gain
  states: {}
- name: sfcwRadar_calibration_0
  id: sfcwRadar_calibration
  parameters:
    cal_fileName: cal_mf_2g_1.npy
    isOff: calibration_off
    num_steps: num_steps
  states: {state: disabled}
- name: sfcwRadar_findPeak_0
  id: sfcwRadar_findPeak
  parameters:
    mf_size: mf_size
  states: {}
- name: sfcwRadar_matchedFilter_0
  id: sfcwRadar_matchedFilter
  parameters:
    mf_size: mf_size
  states: {}
- name: sfcwRadar_rangeProfileSink_1
  id: sfcwRadar_rangeProfileSink
  parameters:
    num_steps: num_steps
    prefix: scan
  states: {state: disabled}
- name: sfcwRadar_rangeProfileSink_1_0
  id: sfcwRadar_rangeProfileSink
  parameters:
    num_steps: num_steps
    prefix: cal_mf_2g
  states: {state: disabled}
- name: sfcwRadar_rawSamplesSink_0
  id: sfcwRadar_rawSamplesSink
  parameters:
    burst_len: burst_len
    chirp_bandwidth: chirp_bandwidth
    cw_amplitude: cw_amp
    cw_frequency: cw_freq
    enable_biastee: 'False'
    file_prefix: chirp
    isChirp: 'True'
    num_steps: num_steps
    recv_buf_len: recv_buf_len
    ref_gain: ref_gain
    rx_gain: rx_gain
    samp_rate: int(samp_rate)
    start_freq: int(start_freq)
    tx_gain: tx_gain
  states: {}
- name: sfcwRadar_rawSignalSink_cc_0
  id: sfcwRadar_rawSignalSink_cc
  parameters:
    burst_len: burst_len
    cw_amplitude: '1'
    cw_frequency: cw_freq
    dir: ../gui/
    freq_step: int(freq_step)
    num_steps: num_steps
    prefix: chirp
    ref_gain: ref_gain
    rx_gain: rx_gain
    samp_rate: int(samp_rate)
    start_freq: int(start_freq)
    tx_gain: tx_gain
  states: {state: disabled}

connections:
- [blocks_complex_to_arg_1, '0', qtgui_time_sink_x_2, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0, '0', sfcwRadar_calibration_0, '0']
- [blocks_stream_to_vector_0, '0', sfcwRadar_rangeProfileSink_1_0, '0']
- [blocks_stream_to_vector_1, '0', sfcwRadar_matchedFilter_0, '0']
- [blocks_stream_to_vector_1_0, '0', sfcwRadar_matchedFilter_0, '1']
- [blocks_stream_to_vector_1_0_0, '0', sfcwRadar_rawSamplesSink_0, '0']
- [blocks_stream_to_vector_1_0_1, '0', sfcwRadar_rawSamplesSink_0, '1']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0, '0', sfcwRadar_rangeProfileSink_1, '0']
- [low_pass_filter_0, '0', blocks_stream_to_vector_1, '0']
- [low_pass_filter_0, '0', blocks_stream_to_vector_1_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [low_pass_filter_0_0, '0', blocks_stream_to_vector_1_0, '0']
- [low_pass_filter_0_0, '0', blocks_stream_to_vector_1_0_1, '0']
- [low_pass_filter_0_0, '0', qtgui_time_sink_x_1, '1']
- [scan_cont, pressed, sfcwRadar_bladerfRadarController_cc_0, scan]
- [scan_once, pressed, sfcwRadar_bladerfRadarController_cc_0, scan]
- [sfcwRadar_bladerfRadarController_cc_0, '0', low_pass_filter_0, '0']
- [sfcwRadar_bladerfRadarController_cc_0, '0', sfcwRadar_rawSignalSink_cc_0, '0']
- [sfcwRadar_bladerfRadarController_cc_0, '1', low_pass_filter_0_0, '0']
- [sfcwRadar_bladerfRadarController_cc_0, '1', sfcwRadar_rawSignalSink_cc_0, '1']
- [sfcwRadar_calibration_0, '0', fft_vxx_0, '0']
- [sfcwRadar_findPeak_0, '0', blocks_complex_to_arg_1, '0']
- [sfcwRadar_findPeak_0, '0', blocks_stream_to_vector_0, '0']
- [sfcwRadar_matchedFilter_0, '0', sfcwRadar_findPeak_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.9.2-39-gcf065ee5
