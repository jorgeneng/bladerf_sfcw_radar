options:
  parameters:
    generate_options: qt_gui
    id: sfcwRadarGUI
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: LP_dec
  id: variable
  parameters:
    value: interpolation_rate
  states: {}
- name: burst_len
  id: variable
  parameters:
    value: 2**10
  states: {}
- name: burst_len
  id: variable_qtgui_entry
  parameters:
    entry_signal: returnPressed
    label: length of each frequency burst
    type: int
    value: 2**12
  states: {state: disabled}
- name: calibration_off
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {state: disabled}
- name: calibration_off
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '0'
  states: {}
- name: cw_amp
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: cw_freq
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: freq_step
  id: variable_qtgui_entry
  parameters:
    entry_signal: returnPressed
    label: Bandwidth of each frequency step
    type: real
    value: 20e6
  states: {state: disabled}
- name: freq_step
  id: variable
  parameters:
    value: 15e6
  states: {}
- name: initial_offset
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '200'
    value: '0'
  states: {state: disabled}
- name: initial_offset
  id: variable
  parameters:
    value: int(burst_len/2)
  states: {}
- name: interpolation_rate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: keep_ratio
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {state: disabled}
- name: keep_ratio
  id: variable
  parameters:
    value: '1'
  states: {}
- name: lowPassTaps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate_interpolated/(interpolation_rate*2)
    gain: '1.0'
    samp_rate: samp_rate_interpolated
    width: samp_rate_interpolated/(interpolation_rate*4)
    win: window.WIN_HAMMING
  states: {}
- name: num_steps
  id: variable
  parameters:
    value: '128'
  states: {}
- name: num_steps
  id: variable_qtgui_entry
  parameters:
    entry_signal: returnPressed
    label: number of frequency steps
    type: int
    value: '128'
  states: {state: disabled}
- name: ref_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: ref_gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '60'
    value: '50'
  states: {state: disabled}
- name: rx_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '60'
    value: '30'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 15e6
  states: {}
- name: samp_rate_interpolated
  id: variable
  parameters:
    value: samp_rate*interpolation_rate
  states: {}
- name: start_freq
  id: variable_qtgui_entry
  parameters:
    entry_signal: returnPressed
    label: starting frequency
    type: real
    value: 1e9
  states: {state: disabled}
- name: start_freq
  id: variable
  parameters:
    value: 2e9
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '40'
  states: {state: disabled}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '150'
    value: '60'
  states: {state: disabled}
- name: tx_gain
  id: variable_qtgui_entry
  parameters:
    entry_signal: returnPressed
    label: TX gain
    type: int
    value: '40'
  states: {state: disabled}
- name: tx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: y_max
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '26000'
    value: '20'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: cw_freq
    minoutbuf: burst_len*2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.4'
    freq: 5e6
    minoutbuf: burst_len*2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_arg_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_1_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int(burst_len*keep_ratio)
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: int(burst_len*keep_ratio)
    n: burst_len
    offset: initial_offset
    type: complex
  states: {state: bypassed}
- name: blocks_keep_m_in_n_0_0
  id: blocks_keep_m_in_n
  parameters:
    m: int(burst_len*keep_ratio)
    n: burst_len
    offset: initial_offset
    type: complex
  states: {state: bypassed}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/num_steps
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/(burst_len*keep_ratio)
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"burst"'
    minoutbuf: burst_len*2
    packet_len: burst_len
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_steps*LP_dec
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"burst"'
    type: complex
  states: {}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"burst"'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_steps*LP_dec
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: num_steps*LP_dec
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.hamming(num_steps*LP_dec)
  states: {}
- name: filter_fft_low_pass_filter_0_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: cw_freq*1.3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: cw_freq/2
    win: window.WIN_HAMMING
  states: {}
- name: filter_fft_low_pass_filter_0_0_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: cw_freq*1.3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: cw_freq/2
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '2'
    grid: 'True'
    gui_hint: 2,2,5,2
    name: '"B-Scan"'
    ncols: num_steps*LP_dec
    nrows: '15'
    samp_rate: samp_rate
    type: float
    update_time: '0.1'
    zmax: y_max
    zmin: '0'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color3: cyan
    gui_hint: 0,0,1,2
    label1: rx_real_rx
    label2: rx_img_rx
    label3: rx_real_ref
    label4: rx_imag_ref
    name: '"Reference/Echo signals in time domain"'
    nconnections: '2'
    size: int(burst_len*num_steps)
    srate: samp_rate_interpolated
    style4: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    color3: cyan
    label1: rx_real_rx
    label2: rx_img_rx
    label3: rx_real_ref
    label4: rx_imag_ref
    name: '"Reference/Echo signals in time domain"'
    nconnections: '2'
    size: int(burst_len*keep_ratio*num_steps)
    srate: samp_rate_interpolated
    style4: '2'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 2,0,5,2
    name: '"Range profile(A-Scan)"'
    size: num_steps*LP_dec
    srate: samp_rate
    type: float
    ymax: y_max
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,2,1,2
    name: '"Phase of each frequency step"'
    size: num_steps*interpolation_rate
    srate: samp_rate
    type: float
    ylabel: Phase
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Phases"'
    size: num_steps*burst_len
    srate: samp_rate
    type: float
    ylabel: Phase
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: LP_dec
    type: ccc
  states: {state: disabled}
- name: scan_cont
  id: variable_qtgui_msg_push_button
  parameters:
    msgName: ''
    type: int
    value: '2'
  states: {}
- name: scan_once
  id: variable_qtgui_msg_push_button
  parameters:
    msgName: ''
    type: int
    value: '1'
  states: {}
- name: sfcwRadar_bladerfRadarController_cc_0
  id: sfcwRadar_bladerfRadarController_cc
  parameters:
    buffer_size: '1024'
    burst_len: burst_len
    chirp_bandwidth: 5e6
    cw_amplitude: cw_amp
    cw_frequency: cw_freq
    freq_step: int(freq_step)
    isChirp: 'False'
    num_buffers: '8'
    num_steps: num_steps
    num_transfers: '4'
    ref_gain: ref_gain
    rx_gain: rx_gain
    samp_rate: int(samp_rate)
    start_freq: int(start_freq)
    ts_inc_recv: '0'
    ts_inc_send: '1'
    ts_inc_tune: '10'
    tx_gain: tx_gain
  states: {}
- name: sfcwRadar_calibration_0
  id: sfcwRadar_calibration
  parameters:
    cal_fileName: ../cal_rx_1.npy
    isOff: calibration_off
    num_steps: num_steps
  states: {state: disabled}
- name: sfcwRadar_rangeProfileSink_0
  id: sfcwRadar_rangeProfileSink
  parameters:
    num_steps: ''
    prefix: ''
  states: {state: disabled}
- name: sfcwRadar_rangeProfileSink_1
  id: sfcwRadar_rangeProfileSink
  parameters:
    num_steps: ''
    prefix: ''
  states: {state: disabled}
- name: sfcwRadar_rawSignalSink_cc_0
  id: sfcwRadar_rawSignalSink_cc
  parameters:
    burst_len: burst_len
    cw_amplitude: '1'
    cw_frequency: cw_freq
    dir: ../gui/
    freq_step: int(freq_step)
    num_steps: num_steps
    prefix: scan
    ref_gain: ref_gain
    rx_gain: rx_gain
    samp_rate: int(samp_rate)
    start_freq: int(start_freq)
    tx_gain: tx_gain
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_complex_to_arg_1, '0', qtgui_time_sink_x_2, '0']
- [blocks_complex_to_arg_1_0, '0', qtgui_time_sink_x_2_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_divide_xx_0, '0', blocks_complex_to_arg_1_0, '0']
- [blocks_divide_xx_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_complex_to_arg_1, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_xx_0_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_tag_gate_0, '0']
- [blocks_keep_m_in_n_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_keep_m_in_n_0_0, '0', blocks_tag_gate_0_0, '0']
- [blocks_keep_m_in_n_0_0, '0', qtgui_time_sink_x_1_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', blocks_integrate_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_multiply_const_xx_0_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_const_xx_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0, '0', sfcwRadar_calibration_0, '0']
- [blocks_tag_gate_0, '0', blocks_divide_xx_0, '0']
- [blocks_tag_gate_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_tag_gate_0_0, '0', blocks_divide_xx_0, '1']
- [blocks_tag_gate_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_vector_to_stream_0, '0', sfcwRadar_rangeProfileSink_0, '0']
- [blocks_vector_to_stream_0, '0', sfcwRadar_rangeProfileSink_1, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [filter_fft_low_pass_filter_0_0, '0', blocks_keep_m_in_n_0_0, '0']
- [filter_fft_low_pass_filter_0_0, '0', qtgui_time_sink_x_1, '1']
- [filter_fft_low_pass_filter_0_0, '0', sfcwRadar_rawSignalSink_cc_0, '1']
- [filter_fft_low_pass_filter_0_0_0, '0', blocks_keep_m_in_n_0, '0']
- [filter_fft_low_pass_filter_0_0_0, '0', qtgui_time_sink_x_1, '0']
- [filter_fft_low_pass_filter_0_0_0, '0', sfcwRadar_rawSignalSink_cc_0, '0']
- [rational_resampler_xxx_0, '0', blocks_stream_to_vector_0, '0']
- [scan_cont, pressed, sfcwRadar_bladerfRadarController_cc_0, scan]
- [scan_once, pressed, sfcwRadar_bladerfRadarController_cc_0, scan]
- [sfcwRadar_bladerfRadarController_cc_0, '0', filter_fft_low_pass_filter_0_0_0, '0']
- [sfcwRadar_bladerfRadarController_cc_0, '1', filter_fft_low_pass_filter_0_0, '0']
- [sfcwRadar_calibration_0, '0', fft_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.9.2-39-gcf065ee5
