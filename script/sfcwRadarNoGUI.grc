options:
  parameters:
    generate_options: no_gui
    id: sfcwRadarNoGUI
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: chirp_bandwidth
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: cut_off
  id: variable
  parameters:
    value: chirp_bandwidth
  states: {}
- name: cw_amp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: cw_freq
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: lp_dec
  id: variable
  parameters:
    value: '1'
  states: {}
- name: mf_size
  id: variable
  parameters:
    value: recv_buf_len
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: chirp_bandwidth/2
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.from_long(2))
    period: '1000'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_steps
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: int(mf_size/lp_dec)
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(mf_size/lp_dec)
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_1_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: recv_buf_len*num_steps
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: recv_buf_len*num_steps
    type: complex
  states: {}
- name: burst_len
  id: parameter
  parameters:
    type: intx
    value: 2**10
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: num_steps
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.hamming(num_steps)
  states: {state: disabled}
- name: freq_step
  id: parameter
  parameters:
    type: eng_float
    value: 20e6
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_off
    decim: lp_dec
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition_width
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_off
    decim: lp_dec
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition_width
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: num_steps
  id: parameter
  parameters:
    type: intx
    value: '128'
  states: {}
- name: range_profile_prefix
  id: parameter
  parameters:
    type: str
    value: /home/hui/rangeProfile/scan
  states: {}
- name: raw_signal_file_prefix
  id: parameter
  parameters:
    type: str
    value: /home/hui/rawSignals/raw
  states: {}
- name: recv_buf_len
  id: parameter
  parameters:
    type: intx
    value: 2**10+256
  states: {}
- name: ref_gain
  id: parameter
  parameters:
    type: intx
    value: '5'
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    type: intx
    value: '40'
  states: {}
- name: server_ip
  id: parameter
  parameters:
    type: str
    value: localhost
  states: {}
- name: server_port
  id: parameter
  parameters:
    type: intx
    value: '9999'
  states: {}
- name: sfcwRadar_bladerfRadarController_cc_0
  id: sfcwRadar_bladerfRadarController_cc
  parameters:
    buffer_size: '2048'
    burst_len: burst_len
    chirp_bandwidth: chirp_bandwidth
    cw_amplitude: cw_amp
    cw_frequency: cw_freq
    enable_biastee: 'True'
    isChirp: 'True'
    num_buffers: '8'
    num_steps: num_steps
    num_transfers: '4'
    recv_buf_len: recv_buf_len
    ref_gain: ref_gain
    rx_gain: rx_gain
    samp_rate: int(samp_rate)
    start_freq: int(start_freq)
    step_size: int(freq_step)
    ts_inc_recv: '0'
    ts_inc_send: '1'
    tx_gain: tx_gain
  states: {}
- name: sfcwRadar_findPeak_0
  id: sfcwRadar_findPeak
  parameters:
    mf_size: int(mf_size/lp_dec)
  states: {state: disabled}
- name: sfcwRadar_matchedFilter_0
  id: sfcwRadar_matchedFilter
  parameters:
    mf_size: int(mf_size/lp_dec)
  states: {state: disabled}
- name: sfcwRadar_rangeProfileSink_1
  id: sfcwRadar_rangeProfileSink
  parameters:
    num_steps: num_steps
    prefix: range_profile_prefix
    server_ip: localhost
    server_port: '9999'
    upload_to_server: upload_to_server
  states: {state: disabled}
- name: sfcwRadar_rawSamplesSink_0
  id: sfcwRadar_rawSamplesSink
  parameters:
    burst_len: burst_len
    chirp_bandwidth: chirp_bandwidth
    cw_amplitude: cw_amp
    cw_frequency: cw_freq
    enable_biastee: 'False'
    file_prefix: raw_signal_file_prefix
    isChirp: 'True'
    num_steps: num_steps
    recv_buf_len: recv_buf_len
    ref_gain: ref_gain
    rx_gain: rx_gain
    samp_rate: int(samp_rate)
    start_freq: int(start_freq)
    tx_gain: tx_gain
  states: {}
- name: start_freq
  id: parameter
  parameters:
    type: eng_float
    value: 2e9
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    type: intx
    value: '50'
  states: {}
- name: upload_to_server
  id: parameter
  parameters:
    type: intx
    value: '1'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, sfcwRadar_bladerfRadarController_cc_0, scan]
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', sfcwRadar_matchedFilter_0, '1']
- [blocks_stream_to_vector_1_0, '0', sfcwRadar_matchedFilter_0, '0']
- [blocks_stream_to_vector_1_0_0, '0', sfcwRadar_rawSamplesSink_0, '1']
- [blocks_stream_to_vector_1_0_1, '0', sfcwRadar_rawSamplesSink_0, '0']
- [fft_vxx_0, '0', sfcwRadar_rangeProfileSink_1, '0']
- [low_pass_filter_0, '0', blocks_stream_to_vector_1, '0']
- [low_pass_filter_0_0, '0', blocks_stream_to_vector_1_0, '0']
- [sfcwRadar_bladerfRadarController_cc_0, '0', blocks_stream_to_vector_1_0_0, '0']
- [sfcwRadar_bladerfRadarController_cc_0, '0', low_pass_filter_0, '0']
- [sfcwRadar_bladerfRadarController_cc_0, '1', blocks_stream_to_vector_1_0_1, '0']
- [sfcwRadar_bladerfRadarController_cc_0, '1', low_pass_filter_0_0, '0']
- [sfcwRadar_findPeak_0, '0', blocks_stream_to_vector_0, '0']
- [sfcwRadar_matchedFilter_0, '0', sfcwRadar_findPeak_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.9.2-39-gcf065ee5
