options:
  parameters:
    generate_options: no_gui
    id: sfcwRadarNoGUI
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: burst_len
  id: variable
  parameters:
    value: 2**11
  states: {}
- name: chirp_bandwidth
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: cut_off
  id: variable
  parameters:
    value: chirp_bandwidth
  states: {}
- name: cw_amp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: cw_freq
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: freq_step
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: lp_dec
  id: variable
  parameters:
    value: '1'
  states: {}
- name: mf_size
  id: variable
  parameters:
    value: recv_buf_len
  states: {}
- name: num_steps
  id: variable
  parameters:
    value: '128'
  states: {}
- name: recv_buf_len
  id: variable
  parameters:
    value: burst_len+512
  states: {}
- name: ref_gain
  id: variable
  parameters:
    value: '5'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: start_freq
  id: variable
  parameters:
    value: 2e9
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: chirp_bandwidth/2
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_steps
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: int(mf_size/lp_dec)
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(mf_size/lp_dec)
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: recv_buf_len*num_steps
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: recv_buf_len*num_steps
    type: complex
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: scan_cont
    target: '2'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: num_steps
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.hamming(num_steps)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_off
    decim: lp_dec
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_off
    decim: lp_dec
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: sfcwRadar_bladerfRadarController_cc_0
  id: sfcwRadar_bladerfRadarController_cc
  parameters:
    buffer_size: '2048'
    burst_len: burst_len
    chirp_bandwidth: chirp_bandwidth
    cw_amplitude: cw_amp
    cw_frequency: cw_freq
    enable_biastee: 'True'
    isChirp: 'True'
    num_buffers: '8'
    num_steps: num_steps
    num_transfers: '4'
    recv_buf_len: recv_buf_len
    ref_gain: ref_gain
    rx_gain: rx_gain
    samp_rate: int(samp_rate)
    start_freq: int(start_freq)
    step_size: int(freq_step)
    ts_inc_recv: '0'
    ts_inc_send: '1'
    tx_gain: tx_gain
  states: {}
- name: sfcwRadar_findPeak_0
  id: sfcwRadar_findPeak
  parameters:
    mf_size: int(mf_size/lp_dec)
  states: {}
- name: sfcwRadar_matchedFilter_0
  id: sfcwRadar_matchedFilter
  parameters:
    mf_size: int(mf_size/lp_dec)
  states: {}
- name: sfcwRadar_rangeProfileSink_1
  id: sfcwRadar_rangeProfileSink
  parameters:
    num_steps: num_steps
    prefix: rangeProfile/scan
    server_ip: localhost
    server_port: '9999'
    upload_to_server: ''
  states: {}
- name: sfcwRadar_rawSamplesSink_0
  id: sfcwRadar_rawSamplesSink
  parameters:
    burst_len: burst_len
    chirp_bandwidth: chirp_bandwidth
    cw_amplitude: cw_amp
    cw_frequency: cw_freq
    enable_biastee: 'False'
    file_prefix: raw
    isChirp: 'True'
    num_steps: num_steps
    recv_buf_len: recv_buf_len
    ref_gain: ref_gain
    rx_gain: rx_gain
    samp_rate: int(samp_rate)
    start_freq: int(start_freq)
    tx_gain: tx_gain
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', sfcwRadar_matchedFilter_0, '1']
- [blocks_stream_to_vector_1_0, '0', sfcwRadar_matchedFilter_0, '0']
- [blocks_stream_to_vector_1_0_0, '0', sfcwRadar_rawSamplesSink_0, '1']
- [blocks_stream_to_vector_1_0_1, '0', sfcwRadar_rawSamplesSink_0, '0']
- [blocks_var_to_msg_0, msgout, sfcwRadar_bladerfRadarController_cc_0, scan]
- [fft_vxx_0, '0', sfcwRadar_rangeProfileSink_1, '0']
- [low_pass_filter_0, '0', blocks_stream_to_vector_1, '0']
- [low_pass_filter_0_0, '0', blocks_stream_to_vector_1_0, '0']
- [sfcwRadar_bladerfRadarController_cc_0, '0', blocks_stream_to_vector_1_0_0, '0']
- [sfcwRadar_bladerfRadarController_cc_0, '0', low_pass_filter_0, '0']
- [sfcwRadar_bladerfRadarController_cc_0, '1', blocks_stream_to_vector_1_0_1, '0']
- [sfcwRadar_bladerfRadarController_cc_0, '1', low_pass_filter_0_0, '0']
- [sfcwRadar_findPeak_0, '0', blocks_stream_to_vector_0, '0']
- [sfcwRadar_matchedFilter_0, '0', sfcwRadar_findPeak_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.9.2-39-gcf065ee5
