options:
  parameters:
    generate_options: hb
    id: new_hier
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: LO_freq
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: LO_freq
    gain0: '20'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"bladerf=0,nchan=2"'
    bb_gain0: '20'
    bb_gain1: '20'
    corr1: '0'
    dc_offset_mode1: '0'
    freq0: LO_freq
    freq1: LO_freq
    gain0: '20'
    gain1: '10'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '20'
    if_gain1: '20'
    iq_balance_mode1: '0'
    nchan: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: '0'
  states: {}

connections:
- [osmosdr_source_0, '0', pad_sink_0, '0']
- [osmosdr_source_0, '1', pad_sink_1, '0']
- [pad_source_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
