options:
  parameters:
    generate_options: qt_gui
    id: cw_radar_simulation
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: LO_freq
  id: variable_qtgui_range
  parameters:
    start: 1e9
    step: 20e6
    stop: 2e9
    value: 1e9
  states: {}
- name: amp
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: burst_len
  id: variable
  parameters:
    value: 2**14
  states: {}
- name: burst_offset
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '1024'
    value: '1'
  states: {}
- name: fft_size_cor
  id: variable
  parameters:
    value: int(burst_len/2)
  states: {}
- name: freq_index
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '1024'
    value: '1'
  states: {}
- name: num_steps
  id: variable
  parameters:
    value: '64'
  states: {}
- name: ob_range
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '0.1'
    stop: '15'
    value: '1'
  states: {}
- name: ob_range_
  id: variable_qtgui_entry
  parameters:
    label: ob_range
    type: real
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15e6
  states: {}
- name: tone_fft_indices
  id: variable
  parameters:
    value: '[int(((samp_rate/2)+tone_freq[0])/(samp_rate/fft_size_cor)),int(tone_freq[1]/(samp_rate/fft_size_cor)+fft_size_cor/2)]'
  states: {}
- name: tone_freq
  id: variable
  parameters:
    value: '[-5e6,5e6]'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp
    freq: tone_freq[0]
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: amp
    freq: tone_freq[1]
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_arg_1_1_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_1_1_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_magphase_0_0
  id: blocks_complex_to_magphase
  parameters:
    vlen: fft_size_cor
  states: {state: disabled}
- name: blocks_complex_to_magphase_2
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int(burst_len/fft_size_cor)
    type: complex
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(burst_len/fft_size_cor)
    type: complex
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: fft_size_cor
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0_1
  id: blocks_keep_one_in_n
  parameters:
    n: fft_size_cor
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_1
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: fft_size_cor
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: tone_fft_indices[1]
    type: complex
  states: {}
- name: blocks_skiphead_0_1
  id: blocks_skiphead
  parameters:
    num_items: tone_fft_indices[0]
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size_cor
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size_cor
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: int(num_steps*2)
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: freq
    target: samp_rate
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size_cor
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size_cor
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: int(num_steps*2)
    type: complex
  states: {}
- name: blocks_vector_to_stream_2
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size_cor
    type: complex
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size_cor
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size_cor)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_size_cor
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size_cor)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: int(num_steps*2)
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.blackmanharris(int(num_steps*2))
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: num_steps
    srate: samp_rate
    type: float
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: num_steps
    srate: samp_rate
    type: float
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"combined"'
    size: int(num_steps*2)
    srate: samp_rate
    type: float
    ylabel: Phase
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"combined"'
    size: int(num_steps*2)
    srate: samp_rate
    type: float
    ylabel: Mag
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_1_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"range_profile"'
    size: int(num_steps*2)
    srate: samp_rate
    type: float
    update_time: '1'
    ylabel: Mag
    ymax: '10000'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_1_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"cor"'
    size: fft_size_cor
    srate: samp_rate
    type: float
    ylabel: Mag
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"cor"'
    size: fft_size_cor
    srate: samp_rate
    type: float
    ylabel: Phase
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    name: '"after cor: mag"'
    vlen: fft_size_cor
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}
- name: qtgui_vector_sink_f_1
  id: qtgui_vector_sink_f
  parameters:
    name: '"after cor: phase"'
    vlen: fft_size_cor
    x_start: '0'
    x_step: '1.0'
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: sfcwRadar_radarTxRxSimulator_0
  id: sfcwRadar_radarTxRxSimulator
  parameters:
    freq_step: 12e6
    num_steps: num_steps
    ob_range: ob_range
    samp_rate: samp_rate
    start_freq: 2e9
    tone_freq: tone_freq
    tune_threshold: burst_len
  states: {}
- name: sfcwRadar_radarTxRx_0
  id: sfcwRadar_radarTxRx
  parameters:
    freq_step: 12e6
    num_steps: num_steps
    rx_gain: '40'
    samp_rate: samp_rate
    start_freq: 2e9
    tune_threshold: int(samp_rate/10)
    tx_gain: '40'
  states: {state: disabled}
- name: sfcwRadar_responseCollector_0
  id: sfcwRadar_responseCollector
  parameters:
    offset: burst_offset
    tagName: '"burst"'
  states: {}
- name: sfcwRadar_responseCollector_0_0
  id: sfcwRadar_responseCollector
  parameters:
    offset: burst_offset
    tagName: '"burst"'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_2, '0']
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_2, '1']
- [analog_sig_source_x_1, '0', blocks_throttle2_0_0, '0']
- [blocks_add_xx_2, '0', sfcwRadar_radarTxRx_0, '0']
- [blocks_complex_to_arg_1_1_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_arg_1_1_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_1_0_0_0_0, '0']
- [blocks_complex_to_magphase_0, '0', qtgui_time_sink_x_1_0_0_0_1, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_x_1_0_0_1, '0']
- [blocks_complex_to_magphase_0_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_complex_to_magphase_0_0, '1', qtgui_vector_sink_f_1, '0']
- [blocks_complex_to_magphase_2, '0', qtgui_time_sink_x_1_0_0_0, '0']
- [blocks_complex_to_magphase_2, '1', qtgui_time_sink_x_1_0_0, '0']
- [blocks_integrate_xx_0, '0', sfcwRadar_responseCollector_0, '0']
- [blocks_integrate_xx_0_0, '0', sfcwRadar_responseCollector_0_0, '0']
- [blocks_interleave_0, '0', blocks_complex_to_magphase_2, '0']
- [blocks_interleave_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_keep_one_in_n_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_keep_one_in_n_0_1, '0', blocks_integrate_xx_0, '0']
- [blocks_multiply_conjugate_cc_1, '0', blocks_complex_to_magphase_0_0, '0']
- [blocks_multiply_conjugate_cc_1, '0', blocks_vector_to_stream_0, '0']
- [blocks_multiply_conjugate_cc_1, '0', blocks_vector_to_stream_0_1, '0']
- [blocks_multiply_conjugate_cc_1, '0', blocks_vector_to_stream_2, '0']
- [blocks_skiphead_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_skiphead_0_1, '0', blocks_keep_one_in_n_0_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_1, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_1, '0']
- [blocks_throttle2_0, '0', sfcwRadar_radarTxRxSimulator_0, '0']
- [blocks_throttle2_0_0, '0', sfcwRadar_radarTxRxSimulator_0, '1']
- [blocks_var_to_msg_0, msgout, sfcwRadar_radarTxRx_0, msgPort]
- [blocks_vector_to_stream_0, '0', blocks_skiphead_0, '0']
- [blocks_vector_to_stream_0_1, '0', blocks_skiphead_0_1, '0']
- [blocks_vector_to_stream_1, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_vector_to_stream_2, '0', blocks_complex_to_magphase_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_1, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_1, '1']
- [fft_vxx_1, '0', blocks_vector_to_stream_1, '0']
- [sfcwRadar_radarTxRxSimulator_0, '0', blocks_stream_to_vector_0_1, '0']
- [sfcwRadar_radarTxRxSimulator_0, '1', blocks_stream_to_vector_0, '0']
- [sfcwRadar_radarTxRx_0, '0', blocks_stream_to_vector_0, '0']
- [sfcwRadar_radarTxRx_0, '0', qtgui_freq_sink_x_0, '0']
- [sfcwRadar_radarTxRx_0, '1', blocks_stream_to_vector_0_1, '0']
- [sfcwRadar_responseCollector_0, '0', blocks_complex_to_arg_1_1_0, '0']
- [sfcwRadar_responseCollector_0, '0', blocks_interleave_0, '0']
- [sfcwRadar_responseCollector_0_0, '0', blocks_complex_to_arg_1_1_0_0, '0']
- [sfcwRadar_responseCollector_0_0, '0', blocks_interleave_0, '1']

metadata:
  file_format: 1
  grc_version: v3.10.9.2-39-gcf065ee5
