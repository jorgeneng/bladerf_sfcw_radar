options:
  parameters:
    generate_options: qt_gui
    id: test_bladerfRadar_cc
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: start_freq
  id: variable_qtgui_range
  parameters:
    start: 800e6
    step: 100e3
    stop: 3e9
    value: 1e9
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 300e3
    maxoutbuf: '4096'
    minoutbuf: '4096'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '1024'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Ref"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Out"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: sfcwRadar_bladerfRadar_cc_0
  id: sfcwRadar_bladerfRadar_cc
  parameters:
    freq_step: int(10e6)
    maxoutbuf: '4096'
    minoutbuf: '4096'
    num_steps: '64'
    rx_gain: '30'
    samp_rate: int(samp_rate)
    start_freq: int(start_freq)
    tune_th: int(samp_rate/10)
    tx_gain: '30'
  states: {}

connections:
- [analog_sig_source_x_0, '0', sfcwRadar_bladerfRadar_cc_0, '0']
- [blocks_complex_to_arg_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_integrate_xx_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_integrate_xx_0, '0']
- [sfcwRadar_bladerfRadar_cc_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [sfcwRadar_bladerfRadar_cc_0, '0', qtgui_time_sink_x_0_0, '0']
- [sfcwRadar_bladerfRadar_cc_0, '1', blocks_multiply_conjugate_cc_0, '1']
- [sfcwRadar_bladerfRadar_cc_0, '1', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-678-g2ccb54a3
