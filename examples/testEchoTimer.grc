options:
  parameters:
    generate_options: qt_gui
    id: testEchoTimer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: burst_len
  id: variable
  parameters:
    value: 2**13
  states: {}
- name: num_steps
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: burst_len
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: num_steps
    srate: samp_rate
    type: float
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: sfcwRadar_bladerfEchoTimer_cc_0
  id: sfcwRadar_bladerfEchoTimer_cc
  parameters:
    buffer_size: '1024'
    burst_len: burst_len
    freq_step: int(20e6)
    num_buffers: '8'
    num_steps: num_steps
    num_transfers: '4'
    ref_gain: '20'
    rx_gain: '20'
    samp_rate: int(samp_rate)
    start_freq: int(1e9)
    tx_gain: '60'
  states: {}

connections:
- [blocks_complex_to_arg_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_integrate_xx_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_integrate_xx_0, '0']
- [sfcwRadar_bladerfEchoTimer_cc_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [sfcwRadar_bladerfEchoTimer_cc_0, '0', qtgui_time_sink_x_1, '0']
- [sfcwRadar_bladerfEchoTimer_cc_0, '1', blocks_multiply_conjugate_cc_0, '1']
- [sfcwRadar_bladerfEchoTimer_cc_0, '1', qtgui_time_sink_x_1, '1']

metadata:
  file_format: 1
  grc_version: v3.10.9.2-39-gcf065ee5
