options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amp
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: burst_len
  id: variable
  parameters:
    value: 2**16
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: int(burst_len/2)
  states: {}
- name: freq_list_0
  id: variable
  parameters:
    value: 4096*10
  states: {}
- name: freq_step
  id: variable
  parameters:
    value: 30e6
  states: {}
- name: integrate_lenth
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: min_output_items
  id: variable
  parameters:
    value: burst_len*2
  states: {}
- name: num_steps
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25e6
  states: {}
- name: start_freq
  id: variable
  parameters:
    value: 1.2e9
  states: {}
- name: tone_fft_indices
  id: variable
  parameters:
    value: '[int(((samp_rate/2)+tone_freq[0])/(samp_rate/fft_size)),int(tone_freq[1]/(samp_rate/fft_size)+fft_size/2)]'
  states: {}
- name: tone_freq
  id: variable
  parameters:
    value: '[-10e6,10e6]'
  states: {}
- name: tune_th
  id: variable
  parameters:
    value: int(samp_rate/20)
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: amp
    freq: tone_freq[0]
    minoutbuf: min_output_items
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: amp
    freq: tone_freq[1]
    minoutbuf: min_output_items
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    minoutbuf: min_output_items
    type: complex
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_magphase_1
  id: blocks_complex_to_magphase
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters:
    vlen: '256'
  states: {state: disabled}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int(burst_len/fft_size)
    type: complex
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(burst_len/fft_size)
    type: complex
  states: {}
- name: blocks_integrate_xx_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: integrate_lenth
    type: complex
  states: {state: disabled}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_interleave_1
  id: blocks_interleave
  parameters:
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: fft_size
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: fft_size
    type: complex
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '2000'
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/integrate_lenth
    type: complex
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: tone_fft_indices[0]
    type: complex
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: tone_fft_indices[1]
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"burst"'
    minoutbuf: min_output_items
    packet_len: burst_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_steps
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_2
  id: blocks_stream_to_vector
  parameters:
    num_items: num_steps*2
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_tag_gate_1_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"burst"'
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_tag_gate_1_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"burst"'
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_tagged_file_sink_1
  id: blocks_tagged_file_sink
  parameters:
    samp_rate: int(samp_rate)
    type: complex
  states: {state: disabled}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: freq
    target: start_freq
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_steps
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_2
  id: blocks_vector_to_stream
  parameters:
    num_items: num_steps*2
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: num_steps
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(num_steps)
  states: {state: disabled}
- name: fft_vxx_2
  id: fft_vxx
  parameters:
    fft_size: num_steps*2
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(num_steps*2)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: num_steps
    srate: '1'
    type: float
    ymax: '200'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"integrate_phase"'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Phase
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"collectedResposePhase"'
    size: num_steps
    srate: samp_rate
    type: float
    ylabel: Phase
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"collectedResposeMag"'
    size: num_steps
    srate: samp_rate
    type: float
    ylabel: Mag
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"combined"'
    size: int(num_steps*2)
    srate: samp_rate
    type: float
    ylabel: Phase
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"integrate_mag"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: num_steps*2
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    size: num_steps
    srate: samp_rate
    type: float
    ylabel: phase
  states: {}
- name: qtgui_time_sink_x_3_0
  id: qtgui_time_sink_x
  parameters:
    size: num_steps
    srate: samp_rate
    type: float
    ylabel: phase
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '256'
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}
- name: sfcwRadar_bladerfRadarBurst_cc_0
  id: sfcwRadar_bladerfRadarBurst_cc
  parameters:
    buffer_size: '2048'
    burst_len: burst_len
    freq_step: int(freq_step)
    minoutbuf: min_output_items
    num_buffers: '8'
    num_steps: num_steps
    num_transfers: '4'
    ref_gain: '20'
    rx_gain: '60'
    samp_rate: int(samp_rate)
    start_freq: int(start_freq)
    tx_gain: '20'
  states: {}
- name: sfcwRadar_radarTxRx_0
  id: sfcwRadar_radarTxRx
  parameters:
    freq_step: freq_step
    num_steps: num_steps
    rx_gain: '30'
    samp_rate: samp_rate
    start_freq: start_freq
    tune_threshold: tune_th
    tx_gain: '40'
  states: {state: disabled}
- name: sfcwRadar_responseCollector_0
  id: sfcwRadar_responseCollector
  parameters:
    offset: int(tune_th/integrate_lenth/2)
    tagName: '"burst"'
  states: {state: disabled}
- name: sfcwRadar_responseCollector_1
  id: sfcwRadar_responseCollector
  parameters:
    offset: '0'
    tagName: '"burst"'
  states: {state: disabled}
- name: sfcwRadar_responseCollector_1_0
  id: sfcwRadar_responseCollector
  parameters:
    offset: '0'
    tagName: '"burst"'
  states: {state: disabled}
- name: sfcwRadar_responseCollector_2
  id: sfcwRadar_responseCollector
  parameters:
    offset: '1'
    tagName: '"burst"'
  states: {state: disabled}
- name: sfcwRadar_responseCollector_2_0
  id: sfcwRadar_responseCollector
  parameters:
    offset: '1'
    tagName: '"burst"'
  states: {state: disabled}

connections:
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_add_xx_0, '0', sfcwRadar_radarTxRx_0, '0']
- [blocks_complex_to_arg_0, '0', qtgui_time_sink_x_3, '0']
- [blocks_complex_to_arg_0_0, '0', qtgui_time_sink_x_3_0, '0']
- [blocks_complex_to_arg_0_0_0, '0', qtgui_time_sink_x_1_0_0_1, '0']
- [blocks_complex_to_mag_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_complex_to_magphase_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_x_1_0, '0']
- [blocks_complex_to_magphase_1, '0', qtgui_time_sink_x_1_1, '0']
- [blocks_complex_to_magphase_1, '1', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_real_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_integrate_xx_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_integrate_xx_0, '0', blocks_interleave_1, '0']
- [blocks_integrate_xx_0, '0', sfcwRadar_responseCollector_1, '0']
- [blocks_integrate_xx_0, '0', sfcwRadar_responseCollector_2, '0']
- [blocks_integrate_xx_0_0, '0', blocks_complex_to_arg_0_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_interleave_1, '1']
- [blocks_integrate_xx_0_0, '0', sfcwRadar_responseCollector_1_0, '0']
- [blocks_integrate_xx_0_0, '0', sfcwRadar_responseCollector_2_0, '0']
- [blocks_integrate_xx_0_0_0, '0', blocks_complex_to_magphase_1, '0']
- [blocks_integrate_xx_0_0_0, '0', blocks_tagged_file_sink_1, '0']
- [blocks_integrate_xx_0_0_0, '0', sfcwRadar_responseCollector_0, '0']
- [blocks_interleave_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_interleave_1, '0', blocks_complex_to_arg_0_0_0, '0']
- [blocks_interleave_1, '0', blocks_stream_to_vector_2, '0']
- [blocks_keep_one_in_n_0, '0', blocks_integrate_xx_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_message_strobe_0, strobe, sfcwRadar_radarTxRx_0, msgPort]
- [blocks_multiply_conjugate_cc_0, '0', blocks_vector_to_stream_1, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_skiphead_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_skiphead_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', sfcwRadar_bladerfRadarBurst_cc_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_1, '0']
- [blocks_stream_to_vector_1, '0', blocks_tag_gate_1_0_0, '0']
- [blocks_stream_to_vector_1_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_2, '0', fft_vxx_2, '0']
- [blocks_tag_gate_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_tag_gate_1_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_tag_gate_1_0_0, '0', fft_vxx_0, '0']
- [blocks_var_to_msg_0, msgout, sfcwRadar_radarTxRx_0, msgPort]
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_skiphead_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_skiphead_0_0, '0']
- [blocks_vector_to_stream_2, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_tag_gate_1_0, '0']
- [fft_vxx_1, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_2, '0', blocks_vector_to_stream_2, '0']
- [sfcwRadar_bladerfRadarBurst_cc_0, '0', blocks_stream_to_vector_1, '0']
- [sfcwRadar_bladerfRadarBurst_cc_0, '1', blocks_stream_to_vector_1_0, '0']
- [sfcwRadar_radarTxRx_0, '0', blocks_stream_to_vector_1, '0']
- [sfcwRadar_radarTxRx_0, '1', blocks_stream_to_vector_1_0, '0']
- [sfcwRadar_responseCollector_0, '0', blocks_complex_to_magphase_0, '0']
- [sfcwRadar_responseCollector_0, '0', blocks_tag_gate_0, '0']
- [sfcwRadar_responseCollector_1, '0', blocks_interleave_0, '0']
- [sfcwRadar_responseCollector_1_0, '0', blocks_interleave_0, '1']
- [sfcwRadar_responseCollector_2, '0', blocks_interleave_1, '0']
- [sfcwRadar_responseCollector_2_0, '0', blocks_interleave_1, '1']

metadata:
  file_format: 1
  grc_version: v3.10.9.2-39-gcf065ee5
