options:
  parameters:
    generate_options: hb_qt_gui
    id: test_obj_simulation
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: tone_freq
  id: variable
  parameters:
    value: '[-5e6,5e6]'
  states: {}
- name: LO_freq
  id: parameter
  parameters:
    label: LO_freq
    type: eng_float
    value: 1e9
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: 4*3.1415926*(LO_freq+tone_freq[0])*ob_range/3e8
  states: {}
- name: blocks_phase_shift_1
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: 4*3.1415926*(LO_freq+tone_freq[1])*ob_range/3e8
  states: {}
- name: ob_range
  id: parameter
  parameters:
    label: ob_range
    type: eng_float
    value: '1.5'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: ref
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in1
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in2
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: intx
    value: int(15e6)
  states: {}

connections:
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [blocks_add_xx_0_0, '0', pad_sink_1, '0']
- [blocks_phase_shift_0, '0', blocks_add_xx_0, '0']
- [blocks_phase_shift_1, '0', blocks_add_xx_0, '1']
- [pad_source_0, '0', blocks_add_xx_0_0, '0']
- [pad_source_0, '0', blocks_phase_shift_0, '0']
- [pad_source_0_0, '0', blocks_add_xx_0_0, '1']
- [pad_source_0_0, '0', blocks_phase_shift_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
