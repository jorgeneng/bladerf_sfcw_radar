options:
  parameters:
    generate_options: qt_gui
    id: test_tagged_stream
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: burst_len
  id: variable
  parameters:
    value: 2**15
  states: {}
- name: min_output_items
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: 1e3
    minoutbuf: min_output_items
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"burst"'
    minoutbuf: min_output_items
    packet_len: burst_len
    type: complex
  states: {state: bypassed}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: freq
    target: burst_len
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: burst_len
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: 1024*2
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: sfcwRadar_bladerfRadarBurst_cc_0
  id: sfcwRadar_bladerfRadarBurst_cc
  parameters:
    freq_step: int(10e6)
    minoutbuf: min_output_items
    num_steps: '64'
    rx_gain: '30'
    samp_rate: int(samp_rate)
    start_freq: int(1e9)
    tx_gain: '30'
  states: {state: disabled}
- name: sfcwRadar_bladerfRadar_cc_0
  id: sfcwRadar_bladerfRadar_cc
  parameters:
    freq_step: int(10e6)
    minoutbuf: min_output_items
    num_steps: '64'
    rx_gain: '-50'
    samp_rate: int(samp_rate)
    start_freq: int(2e9)
    tune_th: int(samp_rate)
    tx_gain: '-50'
  states: {}
- name: sfcwRadar_radarTxRx_0
  id: sfcwRadar_radarTxRx
  parameters:
    freq_step: 10e6
    num_steps: '0'
    rx_gain: '30'
    samp_rate: samp_rate
    start_freq: 800e6
    tune_threshold: int(samp_rate)
    tx_gain: '30'
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [analog_sig_source_x_0, '0', sfcwRadar_radarTxRx_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_throttle2_0, '0', sfcwRadar_bladerfRadarBurst_cc_0, '0']
- [blocks_throttle2_0, '0', sfcwRadar_bladerfRadar_cc_0, '0']
- [blocks_var_to_msg_0, msgout, sfcwRadar_radarTxRx_0, msgPort]
- [sfcwRadar_bladerfRadarBurst_cc_0, '0', qtgui_time_sink_x_0, '0']
- [sfcwRadar_bladerfRadarBurst_cc_0, '1', qtgui_time_sink_x_0, '1']
- [sfcwRadar_bladerfRadar_cc_0, '0', qtgui_time_sink_x_0, '0']
- [sfcwRadar_bladerfRadar_cc_0, '1', qtgui_time_sink_x_0, '1']
- [sfcwRadar_radarTxRx_0, '0', qtgui_time_sink_x_0, '0']
- [sfcwRadar_radarTxRx_0, '1', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-678-g2ccb54a3
