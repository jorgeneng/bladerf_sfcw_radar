options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: freq_list_0
  id: variable
  parameters:
    value: 4096*10
  states: {}
- name: freq_step
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: integrate_lenth
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: num_steps
  id: variable
  parameters:
    value: '128'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '10'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: start_freq
  id: variable
  parameters:
    value: 2.3e9
  states: {}
- name: tone_freq
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: tune_th
  id: variable
  parameters:
    value: int(samp_rate/10)
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '10'
    step: '1'
    stop: '70'
    value: '40'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: amp
    freq: 100e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_magphase_1
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters:
    vlen: '256'
  states: {state: disabled}
- name: blocks_integrate_xx_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: integrate_lenth
    type: complex
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '2000'
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_steps
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"burst"'
    type: complex
  states: {}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"burst"'
    type: complex
  states: {}
- name: blocks_tagged_file_sink_1
  id: blocks_tagged_file_sink
  parameters:
    samp_rate: int(samp_rate)
    type: complex
  states: {state: disabled}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: freq
    target: start_freq
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_steps
    type: complex
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: num_steps
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.blackmanharris(num_steps)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: num_steps
    srate: '1'
    type: float
    ymax: '500'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"integrate_phase"'
    size: '8192'
    srate: samp_rate
    type: float
    ylabel: Phase
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"collectedResposePhase"'
    size: num_steps
    srate: samp_rate
    type: float
    ylabel: Phase
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"collectedResposeMag"'
    size: num_steps
    srate: samp_rate
    type: float
    ylabel: Mag
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"integrate_mag"'
    size: '8192'
    srate: samp_rate
    type: float
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '256'
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}
- name: sfcwRadar_radarTxRx_0
  id: sfcwRadar_radarTxRx
  parameters:
    freq_step: freq_step
    num_steps: num_steps
    rx_gain: rx_gain
    samp_rate: samp_rate
    start_freq: start_freq
    tune_threshold: tune_th
    tx_gain: tx_gain
  states: {}
- name: sfcwRadar_responseCollector_0
  id: sfcwRadar_responseCollector
  parameters:
    offset: int(tune_th/integrate_lenth/1.5)
    tagName: '"burst"'
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', sfcwRadar_radarTxRx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_magphase_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_x_1_0, '0']
- [blocks_complex_to_magphase_1, '0', qtgui_time_sink_x_1_1, '0']
- [blocks_complex_to_magphase_1, '1', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_real_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_integrate_xx_0_0_0, '0', blocks_tag_gate_0_0, '0']
- [blocks_integrate_xx_0_0_0, '0', blocks_tagged_file_sink_1, '0']
- [blocks_integrate_xx_0_0_0, '0', sfcwRadar_responseCollector_0, '0']
- [blocks_message_strobe_0, strobe, sfcwRadar_radarTxRx_0, msgPort]
- [blocks_multiply_conjugate_cc_0_0_0, '0', blocks_integrate_xx_0_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_1, '0']
- [blocks_tag_gate_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_tag_gate_0_0, '0', blocks_complex_to_magphase_1, '0']
- [blocks_var_to_msg_0, msgout, sfcwRadar_radarTxRx_0, msgPort]
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_1, '0', blocks_vector_to_stream_0, '0']
- [sfcwRadar_radarTxRx_0, '0', blocks_multiply_conjugate_cc_0_0_0, '0']
- [sfcwRadar_radarTxRx_0, '0', qtgui_time_sink_x_2, '0']
- [sfcwRadar_radarTxRx_0, '1', blocks_multiply_conjugate_cc_0_0_0, '1']
- [sfcwRadar_responseCollector_0, '0', blocks_complex_to_magphase_0, '0']
- [sfcwRadar_responseCollector_0, '0', blocks_tag_gate_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-678-g2ccb54a3
