options:
  parameters:
    generate_options: qt_gui
    id: testFindPeak
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 300e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '8192'
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '8192'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(8192)
  states: {}
- name: sfcwRadar_findPeak_0
  id: sfcwRadar_findPeak
  parameters:
    vectorSize: '8192'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', sfcwRadar_findPeak_0, '0']
- [sfcwRadar_findPeak_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.9.2-39-gcf065ee5
