options:
  parameters:
    generate_options: qt_gui
    id: example
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: burst_len
  id: variable
  parameters:
    value: 2**13
  states: {}
- name: num_steps
  id: variable
  parameters:
    value: '64'
  states: {}
- name: ref_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 300e3
    minoutbuf: burst_len*2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.4'
    freq: 5e6
    minoutbuf: burst_len*2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: num_steps
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_magphase_1
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: burst_len
    type: complex
  states: {state: disabled}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: burst_len
    type: complex
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: burst_len
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '5324'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"burst"'
    minoutbuf: burst_len*2
    packet_len: burst_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_steps
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: burst_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: burst_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_2
  id: blocks_stream_to_vector
  parameters:
    num_items: num_steps
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"burst"'
    type: complex
  states: {}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"burst"'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    minoutbuf: burst_len*2
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_steps
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: burst_len
    type: complex
  states: {}
- name: blocks_vector_to_stream_2
  id: blocks_vector_to_stream
  parameters:
    num_items: num_steps
    type: float
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: num_steps
    forward: 'False'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(num_steps)
  states: {state: disabled}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: burst_len
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(burst_len)
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: burst_len
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(burst_len)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: num_steps
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(num_steps)
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,2,4,2
    ncols: num_steps
    nrows: '256'
    samp_rate: samp_rate
    type: float
    update_time: '0.1'
    zmax: 5e8
    zmin: 1e7
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: burst_len*num_steps
    srate: samp_rate
    type: float
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: burst_len*num_steps
    srate: samp_rate
    type: float
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: num_steps
    srate: samp_rate
    type: float
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: num_steps
    srate: samp_rate
    type: float
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 2,0,4,2
    size: num_steps
    srate: '1'
    type: float
    ymax: '300'
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,2,2,2
    size: num_steps
    srate: samp_rate
    type: float
    ylabel: Phase
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: burst_len
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_3_0
  id: qtgui_time_sink_x
  parameters:
    size: burst_len
    srate: samp_rate
    type: float
    ylabel: Phase
    ymax: '4'
    ymin: '-4'
  states: {}
- name: scan_cont
  id: variable_qtgui_msg_push_button
  parameters:
    msgName: ''
    type: int
    value: '2'
  states: {}
- name: scan_once
  id: variable_qtgui_msg_push_button
  parameters:
    msgName: ''
    type: int
    value: '1'
  states: {}
- name: sfcwRadar_bladerfRadarBurst_cc_0
  id: sfcwRadar_bladerfRadarBurst_cc
  parameters:
    buffer_size: '1024'
    burst_len: burst_len
    freq_step: int(20e6)
    minoutbuf: burst_len*2
    num_buffers: '8'
    num_steps: num_steps
    num_transfers: '4'
    ref_gain: ref_gain
    rx_gain: rx_gain
    samp_rate: int(samp_rate)
    start_freq: int(1e9)
    tx_gain: tx_gain
  states: {}
- name: sfcwRadar_findPeak_0
  id: sfcwRadar_findPeak
  parameters:
    vectorSize: burst_len
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_complex_to_arg_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_arg_1, '0', qtgui_time_sink_x_2, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_vector_to_stream_2, '0']
- [blocks_complex_to_magphase_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_magphase_1, '0', qtgui_time_sink_x_3, '0']
- [blocks_complex_to_magphase_1, '1', qtgui_time_sink_x_3_0, '0']
- [blocks_integrate_xx_0, '0', blocks_complex_to_arg_1, '0']
- [blocks_integrate_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_stream_to_vector_2, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_vector_to_stream_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', sfcwRadar_findPeak_0, '0']
- [blocks_skiphead_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_1_0, '0', fft_vxx_0_0_0, '0']
- [blocks_stream_to_vector_2, '0', fft_vxx_1, '0']
- [blocks_tag_gate_0, '0', blocks_stream_to_vector_1_0, '0']
- [blocks_tag_gate_0_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_throttle2_0, '0', sfcwRadar_bladerfRadarBurst_cc_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_complex_to_magphase_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_complex_to_magphase_1, '0']
- [blocks_vector_to_stream_1, '0', blocks_skiphead_0, '0']
- [blocks_vector_to_stream_2, '0', qtgui_time_sink_x_1_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_1, '0', blocks_complex_to_mag_squared_1, '0']
- [scan_cont, pressed, sfcwRadar_bladerfRadarBurst_cc_0, scan]
- [scan_once, pressed, sfcwRadar_bladerfRadarBurst_cc_0, scan]
- [sfcwRadar_bladerfRadarBurst_cc_0, '0', blocks_tag_gate_0_0, '0']
- [sfcwRadar_bladerfRadarBurst_cc_0, '1', blocks_tag_gate_0, '0']
- [sfcwRadar_findPeak_0, '0', blocks_complex_to_arg_0, '0']
- [sfcwRadar_findPeak_0, '0', blocks_stream_to_vector_2, '0']

metadata:
  file_format: 1
  grc_version: v3.10.9.2-39-gcf065ee5
