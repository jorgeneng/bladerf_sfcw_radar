options:
  parameters:
    generate_options: qt_gui
    id: example
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: LO_freq
  id: variable_qtgui_range
  parameters:
    start: 800e6
    step: 10e6
    stop: 3e9
    value: 800e6
  states: {}
- name: burst_len
  id: variable
  parameters:
    value: 2**12
  states: {}
- name: num_steps
  id: variable
  parameters:
    value: '64'
  states: {}
- name: ref_gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '20'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '60'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 100e3
    minoutbuf: burst_len*2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.4'
    freq: 5e6
    minoutbuf: burst_len*2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: burst_len
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"burst"'
    minoutbuf: burst_len*2
    packet_len: burst_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_steps
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"burst"'
    type: complex
  states: {}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"burst"'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    minoutbuf: burst_len*2
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_steps
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: num_steps
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(num_steps)
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    ncols: '64'
    nrows: '64'
    samp_rate: samp_rate
    type: float
    update_time: '0.1'
    zmax: 2e8
    zmin: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: burst_len*num_steps
    srate: samp_rate
    type: float
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    size: num_steps
    srate: '1'
    type: float
    ymax: '300'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: num_steps
    srate: samp_rate
    type: float
    ylabel: Phase
    ymax: '4'
    ymin: '-4'
  states: {}
- name: scan_cont
  id: variable_qtgui_msg_push_button
  parameters:
    msgName: ''
    type: int
    value: '2'
  states: {}
- name: scan_once
  id: variable_qtgui_msg_push_button
  parameters:
    msgName: ''
    type: int
    value: '1'
  states: {}
- name: sfcwRadar_bladerfRadarBurst_cc_0
  id: sfcwRadar_bladerfRadarBurst_cc
  parameters:
    buffer_size: '1024'
    burst_len: burst_len
    freq_step: int(30e6)
    minoutbuf: burst_len*2
    num_buffers: '8'
    num_steps: num_steps
    num_transfers: '4'
    ref_gain: ref_gain
    rx_gain: rx_gain
    samp_rate: int(samp_rate)
    start_freq: int(1e9)
    tx_gain: tx_gain
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_complex_to_arg_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_arg_1, '0', qtgui_time_sink_x_2, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_integrate_xx_0, '0', blocks_complex_to_arg_1, '0']
- [blocks_integrate_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_integrate_xx_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_tag_gate_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_tag_gate_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_throttle2_0, '0', sfcwRadar_bladerfRadarBurst_cc_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [scan_cont, pressed, sfcwRadar_bladerfRadarBurst_cc_0, scan]
- [scan_once, pressed, sfcwRadar_bladerfRadarBurst_cc_0, scan]
- [sfcwRadar_bladerfRadarBurst_cc_0, '0', blocks_tag_gate_0_0, '0']
- [sfcwRadar_bladerfRadarBurst_cc_0, '1', blocks_tag_gate_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.9.2-39-gcf065ee5
